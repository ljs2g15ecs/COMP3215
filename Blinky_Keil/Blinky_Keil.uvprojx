# Keil uVision project Blinky_Keil.uvprojx, settings and files
target Blinky_Keil Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKW41Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cproject_templates.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKW41Z512VHT4, CPU_MKW41Z512VHT4_cm0plus, FSL_RTOS_FREE_RTOS, SDK_CORE_ID_CORE0, SDK_OS_FREE_RTOS
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: CMSIS;board;drivers;freertos;startup;utilities
  asm define: as above
  asm include: CMSIS;board;drivers;freertos;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: "MKW41Z512xxx4_flash.scf"
  link misc: --remove
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0plus.h core_cmFunc.h core_cmInstr.h core_cmSimd.h fsl_device_registers.h MKW41Z4.h MKW41Z4_features.h system_MKW41Z4.c system_MKW41Z4.h
  group doc/freertos/portable
    doc/freertos/portable/: readme.txt
  group doc/freertos/source
    doc/freertos/source/: readme.txt
  group drivers
    drivers/: Driver_CAN.h Driver_Common.h Driver_ETH.h Driver_ETH_MAC.h Driver_ETH_PHY.h Driver_Flash.h Driver_I2C.h Driver_MCI.h Driver_NAND.h Driver_SAI.h Driver_SPI.h Driver_USART.h Driver_USB.h Driver_USBD.h Driver_USBH.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_freertos.c fsl_lpuart_freertos.h fsl_port.h
  group freertos
    freertos/: ChangeLogKSDK.txt croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h FreeRTOS_for_Kinetis_SDK_v2.0.txt freertos_tasks_c_additions.h FreeRTOSConfig.h fsl_tickless_generic.h fsl_tickless_lptmr.c fsl_tickless_systick.c heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c list.c list.h mpu_prototypes.h mpu_wrappers.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h StackMacros.h task.h tasks.c timers.c timers.h
  group freertos/License
    freertos/License/: license.txt
  group freertos/Source/portable/Keil
    freertos/Source/portable/Keil/: See-also-the-RVDS-directory.txt
  group source
    source/: main.c
  group startup
    startup/: startup_MKW41Z4.s
  group utilities
    utilities/: fsl_debug_console.c fsl_debug_console.h
target Blinky_Keil Release (ARM-ADS)
  device: MKW41Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.7.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cproject_templates.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKW41Z512VHT4, CPU_MKW41Z512VHT4_cm0plus, FSL_RTOS_FREE_RTOS, SDK_CORE_ID_CORE0, SDK_OS_FREE_RTOS
  c misc: as above
  c include: CMSIS;board;drivers;freertos;startup;utilities
  asm define: CPU_MKW41Z512VHT4, CPU_MKW41Z512VHT4_cm0plus, FSL_RTOS_FREE_RTOS, SDK_CORE_ID_CORE0, SDK_OS_FREE_RTOS
  asm include: CMSIS;board;drivers;freertos;startup;utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: "MKW41Z512xxx4_flash.scf"
  link misc: --remove
